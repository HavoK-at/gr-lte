<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>lte_top_block_siso</value></param>
<param><key>author</key><value>Johannes Demel</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>LTE top level flowgraph SISO</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>N_rb_dl</value></param>
<param><key>value</key><value>6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fftlen</value></param>
<param><key>value</key><value>2048</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>frame_key</value></param>
<param><key>value</key><value>"slot"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>interp_val</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>value</key><value>int(samp_rate/1e4)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pbch_descr_key</value></param>
<param><key>value</key><value>"descr_part"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>(7*fftlen + 160* fftlen/2048 + 6 * (144 * fftlen/2048)) / 0.0005</value></param>
</block>
<block>
<key>lte_mib_unpack_vbm</key>
<param><key>id</key><value>MIB</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_deinterleave</key>
<param><key>id</key><value>blocks_deinterleave_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_head</key>
<param><key>id</key><value>blocks_head_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>num_items</key><value>int(samp_rate * 2)</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>lte_bch_decoder</key>
<param><key>id</key><value>lte_bch_decoder_0</value></param>
</block>
<block>
<key>lte_channel_estimator</key>
<param><key>id</key><value>lte_channel_estimator_0</value></param>
<param><key>estimator_key</key><value>"slot"</value></param>
<param><key>initial_id</key><value>124</value></param>
<param><key>N_rb_dl</key><value>N_rb_dl</value></param>
</block>
<block>
<key>lte_cp_ffo_sync</key>
<param><key>id</key><value>lte_cp_ffo_sync_0</value></param>
<param><key>fftlen</key><value>fftlen</value></param>
</block>
<block>
<key>lte_ofdm_demodulator</key>
<param><key>id</key><value>lte_ofdm_demodulator_0</value></param>
<param><key>fftlen</key><value>fftlen</value></param>
<param><key>ofdm_key</key><value>"slot"</value></param>
<param><key>N_rb_dl</key><value>N_rb_dl</value></param>
</block>
<block>
<key>lte_pbch_decoder</key>
<param><key>id</key><value>lte_pbch_decoder_0</value></param>
<param><key>N_rb_dl</key><value>50</value></param>
</block>
<block>
<key>lte_pcfich_decoder</key>
<param><key>id</key><value>lte_pcfich_decoder_0</value></param>
<param><key>key</key><value>"slot"</value></param>
<param><key>N_rb_dl</key><value>N_rb_dl</value></param>
</block>
<block>
<key>lte_pss_sync</key>
<param><key>id</key><value>lte_pss_sync_0</value></param>
<param><key>fftlen</key><value>fftlen</value></param>
</block>
<block>
<key>lte_sss_sync</key>
<param><key>id</key><value>lte_sss_sync_0</value></param>
<param><key>group_key</key><value>"N_id_2"</value></param>
<param><key>fftlen</key><value>fftlen</value></param>
<param><key>offset_key</key><value>"offset_marker"</value></param>
<param><key>N_rb_dl</key><value>N_rb_dl</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>pre_blocks_file_source_0</value></param>
<param><key>file</key><value>/home/johannes/src/gr-lte/tests/lte_test_data_RX1_NRBDL100.dat</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>pre_rational_resampler_xxx_0</value></param>
<param><key>decim</key><value>1000</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>interp</key><value>interp_val</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>lte_rough_symbol_sync_cc</key>
<param><key>id</key><value>sync_lte_rough_symbol_sync_cc_0</value></param>
<param><key>fftl</key><value>fftlen</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<connection><source_block_id>MIB</source_block_id><sink_block_id>lte_pcfich_decoder_0</sink_block_id><source_key>N_ant</source_key><sink_key>N_ant</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>blocks_head_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_deinterleave_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_deinterleave_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_head_0_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_head_0_0</source_block_id><sink_block_id>sync_lte_rough_symbol_sync_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>pre_rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>sync_lte_rough_symbol_sync_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_bch_decoder_0</source_block_id><sink_block_id>MIB</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>lte_bch_decoder_0</source_block_id><sink_block_id>MIB</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_channel_estimator_0</source_block_id><sink_block_id>lte_pbch_decoder_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>lte_channel_estimator_0</source_block_id><sink_block_id>lte_pcfich_decoder_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>lte_channel_estimator_0</source_block_id><sink_block_id>lte_pbch_decoder_0</sink_block_id><source_key>1</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>lte_channel_estimator_0</source_block_id><sink_block_id>lte_pcfich_decoder_0</sink_block_id><source_key>1</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>lte_cp_ffo_sync_0</source_block_id><sink_block_id>lte_sss_sync_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_ofdm_demodulator_0</source_block_id><sink_block_id>lte_channel_estimator_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_ofdm_demodulator_0</source_block_id><sink_block_id>lte_pbch_decoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_ofdm_demodulator_0</source_block_id><sink_block_id>lte_pcfich_decoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_pbch_decoder_0</source_block_id><sink_block_id>lte_bch_decoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_pss_sync_0</source_block_id><sink_block_id>lte_cp_ffo_sync_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_sss_sync_0</source_block_id><sink_block_id>lte_channel_estimator_0</sink_block_id><source_key>cell_id</source_key><sink_key>cell_id</sink_key></connection>
<connection><source_block_id>lte_sss_sync_0</source_block_id><sink_block_id>lte_pbch_decoder_0</sink_block_id><source_key>cell_id</source_key><sink_key>cell_id</sink_key></connection>
<connection><source_block_id>lte_sss_sync_0</source_block_id><sink_block_id>lte_pcfich_decoder_0</sink_block_id><source_key>cell_id</source_key><sink_key>cell_id</sink_key></connection>
<connection><source_block_id>lte_sss_sync_0</source_block_id><sink_block_id>lte_ofdm_demodulator_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pre_blocks_file_source_0</source_block_id><sink_block_id>blocks_deinterleave_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pre_blocks_file_source_0</source_block_id><sink_block_id>blocks_head_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pre_blocks_file_source_0</source_block_id><sink_block_id>sync_lte_rough_symbol_sync_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pre_rational_resampler_xxx_0</source_block_id><sink_block_id>sync_lte_rough_symbol_sync_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>sync_lte_rough_symbol_sync_cc_0</source_block_id><sink_block_id>lte_pss_sync_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>

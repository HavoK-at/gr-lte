<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>lte_pcfich_decoder</value></param>
<param><key>author</key><value>Johannes Demel</value></param>
<param><key>category</key><value>lte</value></param>
<param><key>description</key><value>hier block combining blocks and parameters to decode PCFICH</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>PCFICH Decoder</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ants</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>style</value></param>
<param><key>value</key><value>"tx_diversity"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tag_key</value></param>
<param><key>value</key><value>"subframe"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>vlen</value></param>
<param><key>value</key><value>16</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>N_rb_dl</value></param>
<param><key>label</key><value>resource blocks</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>50</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>key</value></param>
<param><key>label</key><value>Input key</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>symbol</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>type</key><value>message</value></param>
<param><key>label</key><value>CFI</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>12 * N_rb_dl</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_1</value></param>
<param><key>label</key><value>in1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>12 * N_rb_dl</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_2</value></param>
<param><key>label</key><value>in2</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>12 * N_rb_dl</value></param>
</block>
<block>
<key>lte_pcfich_demux_vcvc</key>
<param><key>id</key><value>pcfich_demux_vcvc_0</value></param>
<param><key>key</key><value>key</value></param>
<param><key>out_key</key><value>tag_key</value></param>
<param><key>N_rb_dl</key><value>N_rb_dl</value></param>
</block>
<block>
<key>lte_pcfich_demux_vcvc</key>
<param><key>id</key><value>pcfich_demux_vcvc_1</value></param>
<param><key>key</key><value>key</value></param>
<param><key>out_key</key><value>tag_key</value></param>
<param><key>N_rb_dl</key><value>N_rb_dl</value></param>
</block>
<block>
<key>lte_pcfich_demux_vcvc</key>
<param><key>id</key><value>pcfich_demux_vcvc_2</value></param>
<param><key>key</key><value>key</value></param>
<param><key>out_key</key><value>tag_key</value></param>
<param><key>N_rb_dl</key><value>N_rb_dl</value></param>
</block>
<block>
<key>lte_layer_demapper_vcvc</key>
<param><key>id</key><value>pcfich_layer_demapper_vcvc_0</value></param>
<param><key>style</key><value>style</value></param>
<param><key>N_ant</key><value>ants</value></param>
<param><key>vlen</key><value>vlen</value></param>
</block>
<block>
<key>lte_descrambler_vfvf</key>
<param><key>id</key><value>pcfich_lte_descrambler_vfvf_0</value></param>
<param><key>initial_seqs</key><value>[[0] * 32] * 10</value></param>
<param><key>tag_key</key><value>tag_key</value></param>
<param><key>vlen</key><value>2 * vlen</value></param>
</block>
<block>
<key>lte_pre_decoder_vcvc</key>
<param><key>id</key><value>pcfich_pre_decoder_vcvc_0</value></param>
<param><key>rxant</key><value>1</value></param>
<param><key>style</key><value>style</value></param>
<param><key>N_ant</key><value>ants</value></param>
<param><key>vlen</key><value>vlen</value></param>
</block>
<block>
<key>lte_qpsk_soft_demod_vcvf</key>
<param><key>id</key><value>pcfich_qpsk_soft_demod_vcvf_0</value></param>
<param><key>vlen</key><value>vlen</value></param>
</block>
<block>
<key>lte_pcfich_scramble_sequencer_m</key>
<param><key>id</key><value>pcfich_scramble_sequencer_m_0</value></param>
</block>
<block>
<key>lte_pcfich_unpack_vfm</key>
<param><key>id</key><value>pcfich_unpack_vfm_0</value></param>
<param><key>key</key><value>tag_key</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>z_pad_source_N_ant</value></param>
<param><key>label</key><value>N_ant</value></param>
<param><key>type</key><value>message</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>z_pad_source_cell_id</value></param>
<param><key>label</key><value>cell_id</value></param>
<param><key>type</key><value>message</value></param>
</block>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>pcfich_demux_vcvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_1</source_block_id><sink_block_id>pcfich_demux_vcvc_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_2</source_block_id><sink_block_id>pcfich_demux_vcvc_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pcfich_demux_vcvc_0</source_block_id><sink_block_id>pcfich_pre_decoder_vcvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pcfich_demux_vcvc_1</source_block_id><sink_block_id>pcfich_pre_decoder_vcvc_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>pcfich_demux_vcvc_2</source_block_id><sink_block_id>pcfich_pre_decoder_vcvc_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>pcfich_layer_demapper_vcvc_0</source_block_id><sink_block_id>pcfich_qpsk_soft_demod_vcvf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pcfich_lte_descrambler_vfvf_0</source_block_id><sink_block_id>pcfich_unpack_vfm_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pcfich_pre_decoder_vcvc_0</source_block_id><sink_block_id>pcfich_layer_demapper_vcvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pcfich_qpsk_soft_demod_vcvf_0</source_block_id><sink_block_id>pcfich_lte_descrambler_vfvf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pcfich_scramble_sequencer_m_0</source_block_id><sink_block_id>pcfich_lte_descrambler_vfvf_0</sink_block_id><source_key>descr</source_key><sink_key>seqs</sink_key></connection>
<connection><source_block_id>pcfich_unpack_vfm_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>CFI</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>z_pad_source_N_ant</source_block_id><sink_block_id>pcfich_layer_demapper_vcvc_0</sink_block_id><source_key>out</source_key><sink_key>N_ant</sink_key></connection>
<connection><source_block_id>z_pad_source_N_ant</source_block_id><sink_block_id>pcfich_pre_decoder_vcvc_0</sink_block_id><source_key>out</source_key><sink_key>N_ant</sink_key></connection>
<connection><source_block_id>z_pad_source_cell_id</source_block_id><sink_block_id>pcfich_scramble_sequencer_m_0</sink_block_id><source_key>out</source_key><sink_key>cell_id</sink_key></connection>
</flow_graph>
